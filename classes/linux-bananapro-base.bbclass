inherit linux-kernel-base
