FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://defconfig"
COMPATIBLE_MACHINE_lemaker = "bananapro"
