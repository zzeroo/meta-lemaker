FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://bananapro_config"
COMPATIBLE_MACHINE_lemaker = "bananapro"
