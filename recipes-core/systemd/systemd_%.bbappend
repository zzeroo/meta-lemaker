# EXTRA_OECONF_append = " --disable-logind"
